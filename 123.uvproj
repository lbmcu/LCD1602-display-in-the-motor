# Keil uVision project 123.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 123 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  group User
    ./User/: 123.c delay.c lcd.c motor.c Uart.c
